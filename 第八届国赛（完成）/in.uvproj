# Keil uVision project in.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: in +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\lib
  group Source Group 1
    ./: 2104010117.c
    ./lib/: iic.h iic.c
